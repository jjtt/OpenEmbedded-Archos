SRC_URI = "file://${BP}.tar.bz2 \
           file://fix_version.patch;patch=1"
PR = "r20"

include tslib.inc
